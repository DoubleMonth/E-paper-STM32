# Keil uVision project epd2in13-demo.uvprojx, settings and files
target epd2in13-demo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: epd2in13-demo +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../BSP;../Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group BSP
    ../BSP/: epd2in13.c epdif.c epdpaint.c imagedata.c
  group Fonts
    ../Fonts/: font8.c font12.c font16.c font20.c font24.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_cortex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc_ex.c
software components: CMSIS:CORE 4.3.0
